# Keil uVision project CCUProject.uvprojx, settings and files
target CCUTest (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CCU +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./CCU.bin  ./Objects/CCU.axf
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HAVE_CONFIG_H,DEBUG,OPT_SPEED,FPM_DEFAULT,STDC_HEADERS,USE_USB_OTG_FS,USE_STM324xG_EVAL,USE_EMBEDDED_PHY,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,DEBUG_WAR_CONSOLE_ON,__APP__
  c include: ..\BaseDrive;..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\STM32F4xx_StdPeriph_Library\STM32F4xx\inc;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOS_BSP;..\UCOS_CONFIG;..\User;..\FATS\src;..\FATS\src\option;..\TMS_RS485_Pro;..\CanFestival-3-8\include;..\CanFestival-3-8\include\STM32;..\CanFestival-3-8\drivers\STM32;..\CanFestival-3-8\can1_master;..\CanFestival-3-8\can2_master;..\CanFestival-3-8\can3_master;..\IAP
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group BaseDrive
    ../BaseDrive/: malloc.c bsp_tim_pwm.c Software_Timer.c stmflash.c adc_temper.c bsp_iwdg.c delay.c i2c_gpio.c sys.c SysTick.c Uart.c RTC_ISL1208.c stm32I2C.c MTD_CCU_CAN3_MCP2515.c MTD_CCU_SPI.c RunLed.c Buzzer.c MTD_CCU_CanAddres.c DebugUart1.c CCU_MasterSlave_Led.c
  group UCOSIII_BSP
    ../UCOS_BSP/: bsp.c bsp.h bsp_os.c bsp_os.h cstartup.s
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx Library
    ../STM32F4xx_StdPeriph_Library/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_SOURCE
    ../UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group TMS_RS485_Pro
    ../TMS_RS485_Pro/: AirConditioningPro.c AirCompressorPro.c AirSystemComPro.c CommunPro.c CRC_CCITT.c DoorControlPro.c PIDSComPro.c BrakeComPro.c ATOComPro.c
  group Readme_Txt
    ../Readme_Txt/: readme.txt
  group CanFestival_src
    ../CanFestival-3-8/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CanOpenDriver
    ../CanFestival-3-8/drivers/STM32/: can_stm32.c timer_stm32.c
  group can1Master
    ../CanFestival-3-8/can1_master/: CAN1Master.c CAN1Master_board.c CCUCAN1Master.c
  group can2Master
    ../CanFestival-3-8/can2_master/: CAN2Master.c CAN2Master_board.c CCUCAN2Master.c
  group can3Master
    ../CanFestival-3-8/can3_master/: CAN3Master.c CAN3Master_board.c CCUCAN3Master.c
  group IAP
    ../IAP/: iap.c IAP_Processor.c IAP_UART.c tools.c
